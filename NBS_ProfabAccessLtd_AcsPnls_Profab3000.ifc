Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-03-21T16:07:38
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.4.0.0 - Alternate UI 16.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Wed Mar 21 16:07:38 2018* Host: NCL-PI12* Database: C:\Users\KunduR\AppData\Local\Temp\{365BB6D9-0C04-4AE1-B25E-0143274C555A}\ifc* Database version: 5507* Database creation date: Wed Mar 21 16:07:37 2018* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Wed Mar 21 16:07:37 2018* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Wed Mar 21 16:07:37 2018* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcDoor: 540x540mm, NBS_ProfabAccessLtd_AcsPnls_Profab3000:540x540mm:303419
In: Level 0
Type - ParameterTakesPrecedence: no; Sizeable: no; Classification: Pr_30_59_36_01 (Uniclass2015); Material: NBS_Concept
Type - BOS_General - Author: NBS; BIMObjectName: NBS_ProfabAccessLtd_AccessPanels_Profab3000_540x540mm; ManufacturerName: Profab Access Ltd; ManufacturerURL: www.profabaccesspanels.co.uk; NBSCertification: www.nationalbimlibrary.com/cert/fjmluvv3; NBSDescription: Access panels; NBSReference: 45-45-00/310; OmniClassCode: 22-08 31 16; OmniClassTitle: Access Panels and Frames; OmniClassVersion: Table 22 2012-05-16; ProductInformation: www.profabaccesspanels.co.uk/access-panels/loft-hatches-aka-loft-access-doors; Revision: n/a; Uniclass2015Code: Pr_30_59_36_01; Uniclass2015Title: Access panels; Uniclass2015Version: Products v1.9; Version: 3
Type - NBS_Data - ClearAccessSize: 440 x 505 mm; Frame: 1.2 mm thick electro-galvanized carbon steel; FrameDepth: 96 mm; FrameOptions: Beaded frame (BF), Picture frame (PF); IntegralAccessories: Push Catch (PC); LatchOrLockType: Manual locking & unlocking; LockingOptions: Budget lock (BL), Push catch (PC), Security lock (SL); LockNumber: 2; Operation: Concealed pivot hinge downward opening; PanelIntegralFinish: Powder coated; PanelType: 0.9 mm thick electro-galvanized carbon steel with 70 mm rigid insulation board bonded to the rear of the door; Position: Ceiling mounted; Weight: 7.0 kg
Type - Pset_DoorCommon - AcousticRating: n/a; DurabilityRating: n/a; FireExit: no; FireRating: n/a; GlazingAreaFraction: 0; HandicapAccessible: no; HasDrive: no; HygrothermalRating: n/a; Infiltration: 0; IsExternal: no; MechanicalLoadRating: n/a; Reference: n/a; SecurityRating: n/a; SelfClosing: no; SmokeStop: no; ThermalTransmittance: 0.38; WaterTightnessRating: n/a; WindLoadRating: n/a
Type - IFC - IfcExportAs: IfcDoorType; IfcExportType: USERDEFINED
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_30_59_36_01:Access panels; CodePerformance: n/a; Color: White; Constituents: n/a; Description: Concealed loft access panel for plasterboard/ plaster ceilings; DurationUnit: year; ExpectedLife: n/a; Features: Rubber draught seals to all sides, Fully adjustable hinges; Finish: n/a; Grade: n/a; Manufacturer: technical@profabaccess.com; Material: Carbon steel; ModelNumber: n/a; ModelReference: Profab 3000; Name: AccessPanels_Profab3000_540x540mm_ProfabAccessLtd; NominalHeight: 540 mm; NominalLength: 540 mm; NominalWidth: 540 mm; ReplacementCost: n/a; Shape: n/a; Size: 540 x 540 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
OverallHeight: 844.8 mm; OverallWidth: 585 mm
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
